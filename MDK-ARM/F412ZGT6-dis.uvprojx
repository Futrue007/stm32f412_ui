# Keil uVision project F412ZGT6-dis.uvprojx, settings and files
target F412ZGT6-dis (ARM-ADS)
  device: STM32F412ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: F412ZGT6-dis
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F412Zx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Drivers/CMSIS/Include;..\pace_app\inc;..\pace_bsp\inc;..\pace_common\inc;..\pace_hal\inc
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  link misc: --diag_suppress=L6329
  group Drivers
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_pwr.c stm32f4xx_hal_tim.c stm32f4xx_hal_flash.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_dma.c
  group Middlewares
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: timers.c tasks.c list.c croutine.c queue.c event_groups.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Src
    ../Src/: main.c freertos.c stm32f4xx_it.c stm32f4xx_hal_msp.c system_stm32f4xx.c
    ./: startup_stm32f412zx.s
  group Pace_Common
    ../pace_common/src/: pace_task.c pace_log.c pace_msg.c pace_timer.c
  group Pace_App
    ../pace_app/src/: pace_atcmd_task.c pace_gui_task.c pace_time_sys_task.c
  group Pace_Hal
    ../pace_hal/src/: pace_hal_rtc.c
  group Pace_Bsp
    ../pace_bsp/src/: pace_bsp_rtc.c pace_bsp_uart.c pace_bsp.c pace_key.c pace_gpio.c
software components: CMSIS:CORE 4.1.0
